# Keil uVision project firmware_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3246PVI-147 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: firmware_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h MOTOR_EN.c MOTOR_EN.h MOTOR_EN_aliases.h UART_RS485.c UART_RS485.h UART_RS485_PM.c UART_RS485_INT.c RS_485_EN.c RS_485_EN.h RS_485_EN_aliases.h AMUXSEQ_MOTORS.c AMUXSEQ_MOTORS.h Signal_2_C.c Signal_2_C.h Signal_2_C_aliases.h CURRENT_SENSE_2.c CURRENT_SENSE_2.h CURRENT_SENSE_2_aliases.h CURRENT_SENSE_1.c CURRENT_SENSE_1.h CURRENT_SENSE_1_aliases.h CLOCK_CONTROL.c CLOCK_CONTROL.h ISR_RS485_RX.c ISR_RS485_RX.h ISR_MOTORS_CONTROL.c ISR_MOTORS_CONTROL.h ISR_MEASUREMENTS.c ISR_MEASUREMENTS.h CLOCK_MEASUREMENTS.c CLOCK_MEASUREMENTS.h CLOCK_UART.c CLOCK_UART.h COUNTER_ENC.c COUNTER_ENC.h COUNTER_ENC_PM.c SHIFTREG_ENC_1.c SHIFTREG_ENC_1.h SHIFTREG_ENC_1_PM.c CLOCK_ENCODERS.c CLOCK_ENCODERS.h Signal_1_C.c Signal_1_C.h Signal_1_C_aliases.h SHIFTREG_ENC_2.c SHIFTREG_ENC_2.h SHIFTREG_ENC_2_PM.c SHIFTREG_ENC_3.c SHIFTREG_ENC_3.h SHIFTREG_ENC_3_PM.c EEPROM.c EEPROM.h USB_VDD.c USB_VDD.h USB_VDD_aliases.h FTDI_ENABLE.c FTDI_ENABLE.h FTDI_ENABLE_aliases.h VOLTAGE_SENSE.c VOLTAGE_SENSE.h VOLTAGE_SENSE_aliases.h Signal_2_B_aliases.h Signal_3_B_aliases.h Signal_1_B_aliases.h Signal_3_C.c Signal_3_C.h Signal_3_C_aliases.h ADC.c ADC.h ADC_PM.c ADC_INT.c Signal_1_A.c Signal_1_A.h Signal_1_A_aliases.h Signal_2_A.c Signal_2_A.h Signal_2_A_aliases.h Signal_3_A.c Signal_3_A.h Signal_3_A_aliases.h RS485_CTS.c RS485_CTS.h ADC_theACLK.c ADC_theACLK.h ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h ADC_AMux.c ADC_AMux.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h ISR_ENCODER.c ISR_ENCODER.h UART_RS485_BOOT.c Signal_2_B.c Signal_2_B.h Signal_3_B.c Signal_3_B.h Signal_1_B.c Signal_1_B.h cydisabledsheets.h ADC_IRQ.c ADC_IRQ.h MOTOR_1A.c MOTOR_1A.h MOTOR_1A_aliases.h MOTOR_2A.c MOTOR_2A.h MOTOR_2A_aliases.h PWM_MOTORS.c PWM_MOTORS.h PWM_MOTORS_PM.c CLOCK_PWM.c CLOCK_PWM.h MOTOR_1B.c MOTOR_1B.h MOTOR_1B_aliases.h MOTOR_2B.c MOTOR_2B.h MOTOR_2B_aliases.h MOTOR_DIR.c MOTOR_DIR.h MOTOR_ON_OFF.c MOTOR_ON_OFF.h CLOCK_ENCODER_READ.c CLOCK_ENCODER_READ.h ISR_CALIBRATE.c ISR_CALIBRATE.h CALIB_TRIGG.c CALIB_TRIGG.h timer_clock.c timer_clock.h MY_TIMER.c MY_TIMER.h MY_TIMER_PM.c ISR_DELAY.c ISR_DELAY.h LED_REG.c LED_REG.h LED.c LED.h LED_aliases.h EMG_1.c EMG_1.h EMG_1_aliases.h EMG_2.c EMG_2.h EMG_2_aliases.h
target Release (MCS-51)
  device: CY8C3246PVI-147 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: firmware_PSoC3lib (library)
  c flags: Optimize=8 SizeSpeed=1
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
